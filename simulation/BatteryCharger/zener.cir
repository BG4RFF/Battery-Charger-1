* simulation of zener
.control
  set filetype=ascii
  tran 100us 100ms

write
.endc
.include /home/ksarkies/Electronics-Development/spice-models/diodes
.include /home/ksarkies/Electronics-Development/spice-models/
.include /home/ksarkies/Electronics-Development/spice-models/bjt
.include /home/ksarkies/Electronics-Development/spice-models/IR
.include /home/ksarkies/Electronics-Development/spice-models/bjt/2N3904.mod
.include zener.net
