* simulation of ConstantCurrentTestDiode-2
.control
  set filetype=ascii
  dc vbattery 0 24 0.1

write
.endc
.include ConstantCurrentTestDiode-2.net
